Commit message: fix right wheel inertia measurements

File: robot.urdf (robot description, URDF)
Before this commit: robot balance, 3 links, 2 joints
Links:
- link r_wheel: mass 0.1 -> 0.0385
